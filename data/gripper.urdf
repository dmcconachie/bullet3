Commit message: Added radius grab.

File: data/gripper.urdf (robot description, URDF)
Before this commit: robot gripper, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.1 0.1 0.02; collision box size=0.1 0.1 0.02
